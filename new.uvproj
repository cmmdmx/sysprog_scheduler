# Keil uVision project new.uvproj, settings and files
target Target 1 (MCS-51)
  device: C517A-L Infineon
  cpu: IRAM(0-0xFF) CLOCK(24000000) MOD517DP MOD517AU XRAM(0xF800-0xFFFF)
  output: new
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.a51 process_a.a51 process_b.a51 process_c.a51 init.a51 process_z.a51 scheduler.a51
